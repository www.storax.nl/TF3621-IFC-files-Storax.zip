Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 158eba9f-149e-4e31-a093-e8ad407493e0, NumberOfSaves: 1]
File name: Project Number
Time: 2026-01-30T17:30:45+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family10:Standard, Family10:Standard:209527
In: Level 1
Type - Material: Aluminum - Flat
Type - Other - Category: Generic Models; Family Name: Family10
Type - Model Properties - Artikelnummer: 10362141010; Author: NW; Creation Date: 05/09/2025; Designer: NW; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX TL-3621 Endkappe links mit Abdeckkappe Aluminium unbehandelt; OnLevel description DK: TURBOFLEX TL-3621 endekappe venstre med dækkappe aluminium rå overfl.; OnLevel description EN: TURBOFLEX TL-3621 endcap left with covercap aluminum mill finish; OnLevel description ES: TURBOFLEX TL-3621 tapón de acabado izq. con cubierta aluminio sin tratar; OnLevel description FR: TURBOFLEX TL-3621 bouchon gauche avec couvert. aluminium non traitée; OnLevel description GB: TURBOFLEX TL-3621 endcap left with covercap aluminum mill finish; OnLevel description NL: TURBOFLEX TL-3621 eindkap links met afdekkap aluminium onbehandeld; OnLevel description NO: TURBOFLEX TL-3621 endekap venstre med dekklokk aluminium rå overflate; OnLevel description RU: TURBOFLEX TL-3621 плоская крышка оставил сучаст. крышка oтделка алюм. mель.; OnLevel description SE: TURBOFLEX TL-3621 ändlock vänster med täcklock aluminium obehand. utför.; OnLevel description US: TURBOFLEX TL-3621 endcap left with covercap aluminum mill finish; Part Number: 10362141010; Title: 10362141010; toleranzangabe: ISO 2768 - m
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family10; Family and Type: Family10: Standard; Type: Standard; Type Id: 209512
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0211522 m2; Volume: 0.0000396274 m3
Phasing - Phase Created: New Construction
