Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 4c9fe583-e805-433d-922d-34b16e7b2f6e, NumberOfSaves: 1]
File name: Project Number
Time: 2026-01-30T17:32:52+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family18:Standard, Family18:Standard:209527
In: Level 1
Type - Material: Aluminum - Flat
Type - Other - Category: Generic Models; Family Name: Family18
Type - Model Properties - Artikelnummer: 10362146110; Author: NW; Creation Date: 05/09/2025; Designer: NW; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TF-3621 Endkappe rechts mit Abdeckkappe Treppe Aufg., Aluminium unbehandelt; OnLevel description DK: TF-3621 endekappe højre med dækkappe til trappe, aluminium rå overfl.; OnLevel description EN: TF-3621 endcap right with covercap for stairway, aluminum mill finish; OnLevel description ES: TF-3621 tapón de acabado der. con cubierta para escaleras, aluminio sin tratar; OnLevel description FR: TF-3621 bouchon droite avec couvert. pour les escaliers, aluminium non traitée; OnLevel description GB: TF-3621 endcap right with covercap for stairway, aluminum mill finish; OnLevel description NL: TF-3621 eindkap rechts met afdekkap trap opgang, aluminium onbehandeld; OnLevel description NO: TF-3621 endekap høyre med dekklokk for trappe, aluminium rå overflate; OnLevel description RU: TF-3621 плоская крышка правильно сучаст. крышка Для лестницы, oтделка алюм. mель.; OnLevel description SE: TF-3621 ändlock höger med täcklock för trappa, aluminium obehand. utför.; OnLevel description US: TF-3621 endcap right with covercap for stairway, aluminum mill finish; Part Number: 10362146110; Title: 10362146010; toleranzangabe: ISO 2768 - m
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family18; Family and Type: Family18: Standard; Type: Standard; Type Id: 209512
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0328446 m2; Volume: 0.0000622019 m3
Phasing - Phase Created: New Construction
