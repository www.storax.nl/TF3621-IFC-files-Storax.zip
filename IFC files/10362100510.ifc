Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: c6e212ff-0438-48b5-891e-cd2e10ee4a0a, NumberOfSaves: 1]
File name: Project Number
Time: 2026-01-30T17:27:43+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family2:Standard, Family2:Standard:209531
In: Level 1
Type - Material: Aluminum - Flat
Type - Other - Category: Generic Models; Family Name: Family2
Type - Model Properties - Artikelnummer: 10362100510; Author: NW; Creation Date: 09/09/2025; Designer: NW; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TF-3621 Glas Profil L=5000mm, Aluminium unbehandelt; OnLevel description DK: TF-3621 glasprofil L=5000mm, aluminium rå overfl.; OnLevel description EN: TF-3621 glass profile L=5000mm, aluminum mill finish; OnLevel description ES: TF-3621 perfil de vidrio L=5000mm, aluminio sin tratar; OnLevel description FR: TF-3621 profil verre L=5000mm, aluminium non traitée; OnLevel description GB: TF-3621 glass profile L=5000mm, aluminum mill finish; OnLevel description NL: TF-3621 glas profiel L=5000mm, aluminium onbehandeld; OnLevel description NO: TF-3621 glassprofil L=5000mm, aluminium rå overflate; OnLevel description RU: TF-3621 профиль стекла L=5000mm, oтделка алюм. mель.; OnLevel description SE: TF-3621 glasprofil L=5000mm, aluminium obehand. utför.; OnLevel description US: TF-3621 glass profile L=5000mm, aluminum mill finish; Part Number: 10362100510; Revision Number: 02; Revisionsnummer: 02; Title: 10362100510; Toleranzangabe: DIN EN 12020 - 2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family2; Family and Type: Family2: Standard; Type: Standard; Type Id: 209516
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 4.21243 m2; Volume: 0.0178777 m3
Phasing - Phase Created: New Construction
